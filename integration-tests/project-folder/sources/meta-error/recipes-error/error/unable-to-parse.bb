# WARNING: [file-path]: Error during finalise of [file-path]
# ERROR: Unable to parse [file-path]
# [multiline-error-info]
# SyntaxError: [error-reason]
LICENSE="GPL-2.0-only"
python do_compile() {
    garbage(code
}