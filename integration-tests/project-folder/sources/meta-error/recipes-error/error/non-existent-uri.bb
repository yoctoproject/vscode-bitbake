# ERROR: [file-path]: Unable to get checksum for [recipe] SRC_URI entry non-existent-uri: file could not be found
# The following paths were searched:
# [...stack of file paths]


SRC_URI = "file://non-existent-uri" 