# ERROR: Variable BB_ENV_EXTRAWHITE has been renamed to BB_ENV_PASSTHROUGH_ADDITIONS (file: [file-path] line: [line-number])
BB_ENV_EXTRAWHITE = "deprecated var"