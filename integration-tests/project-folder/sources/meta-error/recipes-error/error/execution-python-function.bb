# ERROR: [file-path]: Error executing a python function in  <code>:
# [multiline-error-info]
# Exception: TypeError: [error-reason]
LICENSE="GPL-2.0-only"
python() {
    '2' + 2
}