do_install:append() {
    echo "generic version append"
}
