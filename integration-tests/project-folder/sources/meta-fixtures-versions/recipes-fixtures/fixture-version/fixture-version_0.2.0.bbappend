do_install:append() {
    echo "specific version append"
}
