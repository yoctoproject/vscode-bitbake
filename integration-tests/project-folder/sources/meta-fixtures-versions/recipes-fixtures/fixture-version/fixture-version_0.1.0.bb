DESCRIPTION = "Dummy recipe for testing recipe versions"
LICENSE = "MIT"

SRC_URI = ""
PV = "0.1.0"

do_install() {
    echo "hello"
}
