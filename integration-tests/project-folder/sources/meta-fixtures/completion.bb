python do_foo(){
    p
}

do_bar(){
    e
}

DESCRIP
