= 

??= 

?= 

:=  

.=

=.

,

W ??= "x"

A := "${W}" # Immediate variable expansion

C = "${W}"

W ?= "i"

W = "i"

W += "y"

W = " y"

B .= "additionaldata"

C =. "test"

FOO := "${@foo()}"

