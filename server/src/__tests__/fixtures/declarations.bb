FOO = '123'
BAR:o1:o2 = '456'

python my_func:o1:o2(){
    pass
}