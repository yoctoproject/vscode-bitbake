SUMMARY = "i.MX M4 core Demo images"

python do_foo(){
    print('123')
}

do_bar(){
    echo '123'
}
