DESCRIPTION = 'baz.bbclass'

# comment 1 for MYVAR in baz.bbclass
MYVAR = '456'